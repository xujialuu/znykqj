# Keil uVision project 智能云考勤机.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8a的指纹程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c FPM10A.c lcd_12864.c led.c uart.c keyboard.c offline.c voice.c ov7670.c sccb.c WIFI.c
